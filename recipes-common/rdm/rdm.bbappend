DEPENDS:remove = "mountutils"

EXTRA_OECONF:remove = "--enable-mountutils"
