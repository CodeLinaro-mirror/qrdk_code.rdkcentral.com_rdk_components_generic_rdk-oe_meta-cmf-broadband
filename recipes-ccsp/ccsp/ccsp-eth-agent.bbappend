CFLAGS:append = " -Wno-unused-variable -Wno-unused-function "
CFLAGS_aarch64:append = " -Werror=format-truncation=1 "
