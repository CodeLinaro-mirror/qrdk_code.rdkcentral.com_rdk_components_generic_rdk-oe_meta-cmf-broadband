DEPENDS:append = " libbsd libunpriv"
LDFLAGS:append = " -lbsd -lprivilege"
