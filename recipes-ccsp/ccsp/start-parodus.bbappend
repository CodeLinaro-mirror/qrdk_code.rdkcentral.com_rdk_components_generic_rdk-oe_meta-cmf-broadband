inherit coverity

DEPENDS:remove = "cpgc"
DEPENDS:remove = "lxy"
