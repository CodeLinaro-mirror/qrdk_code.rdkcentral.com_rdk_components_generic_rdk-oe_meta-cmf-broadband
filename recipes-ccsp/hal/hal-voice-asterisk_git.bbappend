inherit coverity

RDEPENDS_${PN}:remove = "asterisk"
