PACKAGECONFIG:remove_kirkstone  = "librsvg"
