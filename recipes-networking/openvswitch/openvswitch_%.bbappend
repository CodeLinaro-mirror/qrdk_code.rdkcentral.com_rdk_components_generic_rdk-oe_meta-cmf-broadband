SRC_URI:remove = "file://CVE-2021-3905_fix.patch"
SRC_URI:remove_kirkstone = "file://CVE-2021-36980_fix.patch"
