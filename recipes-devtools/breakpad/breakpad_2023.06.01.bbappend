FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += " file://breakpad_processname_revised_wrynose.patch"

