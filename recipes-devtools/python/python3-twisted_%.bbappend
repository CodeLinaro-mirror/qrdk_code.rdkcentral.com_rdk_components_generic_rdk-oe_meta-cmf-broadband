RDEPENDS:${PN}-conch:remove_kirkstone = "${PYTHON_PN}-cryptography"
