FILES:${PN} += "${base_libdir}/rdk/"

